# Keil uVision project TelecarRemoteControl.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: RemoteControl +hex
  c flags: Optimize=8
  group Source Group 1
    ./: MainRemoteControl.c
