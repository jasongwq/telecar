# Keil uVision project EX.uvprojx, settings and files
target CODE (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EX
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\GLIB\SYSTEM;..\GLIB\HARDWARE;..\GLIB\STM32F10x_StdPeriph_Driver\inc;.\USER;..\GLIB\CMSIS\CM3\CoreSupport;.\USER\APP;..\GLIB\PERIPHERAL\LCD\lcd12864;..\GLIB\PERIPHERAL\DHT11;..\GLIB\PERIPHERAL\SD;..\GLIB\FATFS\src;..\GLIB\FATFS\exfuns;..\GLIB\PERIPHERAL\LCD;..\GLIB\PERIPHERAL\DS18B20;.\USER\CONFIG;..\GLIB\PERIPHERAL\ULTRASONIC;..\GLIB\PERIPHERAL\HMC5883L;..\GLIB\PERIPHERAL\MPU6050;.\USER\APP\Kalman_Fliter;..\GLIB\ALGORITHM\aes_rc6_rsa_tea_sha1_sha256_md5\AES;.\USER\TASK
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../GLIB/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../GLIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s startup_stm32f10x_hd.s startup_stm32f10x_cl.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
    ./: README.md
  group FWLIB
    ../GLIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dac.c
  group USER
    ./USER/: stm32f10x_it.c system_stm32f10x.c stm32_config.h main.cpp
  group Config
    ./USER/CONFIG/: ADC_Config.h G32_Timer_Config.h
  group TASK
    ./USER/TASK/: loop_fast.h TaskEx.h task_led.h
  group SYSTEM
    ../GLIB/SYSTEM/: sys.c usart.c minos_delay.c sys_usart.c usr_usart.c sys_os.c
  group HARDWARE
    ../GLIB/HARDWARE/: G32_Timer.c gpio.c
  group APP
    ./USER/APP/Kalman_Fliter/: kalman.c
  group COMMUNICATION
    ./USER/APP/: data_transfer.c
  group ALGORITHM
    ../GLIB/ALGORITHM/aes_rc6_rsa_tea_sha1_sha256_md5/AES/: AES.c
